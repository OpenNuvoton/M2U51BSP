# Keil uVision project TIMER_PWM_AccumulatorINTTriggerPDMA.uvprojx, settings and files
target TIMER_PWM_AccumulatorINTTriggerPDMA (6190000::V6.19::ARMCLANG)
  device: M2U54KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.27
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: TIMER_PWM_AccumulatorINTTriggerPDMA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M2U51\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M2U51\Source\ARM\APROM.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2U51/Source/ARM/: startup_M2U51.c
    ../../../../Library/Device/Nuvoton/M2U51/Source/: system_M2U51.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c timer_pwm.c pdma.c
